# Keil uVision project C_demo_KEA128.uvprojx, settings and files
target C_demo_KEA128 (ARM-ADS)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: C_demo_KEA128 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Sources/: main.c CLK.c GPIO_cfg.c
    ./Sources/Deserialize/: deserialize_data.c deserialize_ctrl.c deserialize_if.c deserialize_I2C.c
    ./Sources/CTP/: CTP_ctrl.c CTP_data.c CTP_I2C.c CTP_if.c atmel_1189.c
    ./Headers/: i2c.c nvic.c adc.c kbi.c
    ./Sources/EEPROM/: EEPROM_ctrl.c EEPROM_data.c EEPROM_I2C.c EEPROM_if.c
    ./Sources/LED/: LED_ctrl.c LED_data.c LED_I2C.c LED_if.c
    ./Sources/LCD/: LCD_ctrl.c LCD_data.c LCD_if.c LCD_spi.c
    ./Sources/ADC/: ADC_ctrl.c ADC_data.c ADC_if.c
    ./Sources/KBI/: KBI_if.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
